## config/boards/shields/maximadness/Kconfig.defconfig
```kconfig
if SHIELD_MAXIMADNESS

config ZMK_KEYBOARD_NAME
    string
    default "Maxi Madness"

endif
```
